# Keil uVision project VSM_Driver_Final_V1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F334C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TestAC6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F334x8
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\Libraries\CMSIS\Device\ST\STM32F30x\Source\Templates\arm;..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\Libraries\STM32F30x_StdPeriph_Driver\src;.\Include;..\VSM_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\TestAC6.sct
  group STD_Lib
    ../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_adc.c stm32f30x_exti.c
  group User
    ./: Circuler_Buffer.c Circuler_Buffer.h main.c main.h stm32f30x_it.c stm32f30x_it.h SysTick_Delay.c SysTick_Delay.h UART_function.c UART_function.h User_GPIO.c User_GPIO.h ADC_function.c ADC_function.h system_stm32f30x.c
  group startup
    ../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f334x8.s
software components: CMSIS:CORE 5.4.0
